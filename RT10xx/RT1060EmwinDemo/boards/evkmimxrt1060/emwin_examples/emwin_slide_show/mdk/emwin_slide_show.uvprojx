# Keil uVision project emwin_slide_show.uvprojx, settings and files
target emwin_slide_show flexspi_nor_sdram_debug (6130001::V6.13.1::.\ARMCLANG)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.12.2.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: emwin_slide_show.out
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, DEBUG, CPU_MIMXRT1062DVL6A, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb -fgnu
  c include: ..;../../..;../../../../../CMSIS/Include;../../../../../devices;../../../../../middleware/emwin/emWin_Config;../../../../../middleware/emwin/emWin_header;../../../../../devices/MIMXRT1062/drivers;../../../../../components/ft5406_rt;../../../../../devices/MIMXRT1062;../../../../../devices/MIMXRT1062/utilities/str;../../../../../devices/MIMXRT1062/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../devices/MIMXRT1062/xip;../../../xip;../../../../../devices/MIMXRT1062/utilities;..\..\..\..\..\middleware\awtk\awtk\src
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor_sdram.scf
  link misc: ../../../../../middleware/emwin/emWin_library/Keil/emWin_M7.lib --remove --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group source
    ../: emwin_slide_show.c
    ../../../../../emwin/Application/: GUIDEMO_Start.c GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c GUIDEMO_Listview.c
    ../../../../../emwin/Config/: SIMConf.c
  group Resources
    ../: Resource.h bmNXP_110x44.c bmSeggerLogo_110x55.c bmBell_40x40.c bmBell_60x60.c bmArrowLeft_23x24.c bmArrowRight_23x24.c bmRainy_45x34.c bmStormy_45x34.c bmSunny_45x34.c AA4_B_20.c AA4_B_40.c AA4_B_100.c Font_13_R.c
  group board
    ../: pin_mux.c pin_mux.h emwin_support.c emwin_support.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_elcdif.c fsl_elcdif.h fsl_pxp.c fsl_pxp.h fsl_lpi2c.c fsl_lpi2c.h fsl_gpt.c fsl_gpt.h fsl_common.c fsl_common.h fsl_clock.c fsl_clock.h fsl_lpuart.c fsl_lpuart.h fsl_iomuxc.h fsl_gpio.c fsl_gpio.h
  group touchpanel
    ../../../../../components/ft5406_rt/: fsl_ft5406_rt.c fsl_ft5406_rt.h
  group device
    ../../../../../devices/MIMXRT1062/: MIMXRT1062.h MIMXRT1062_features.h fsl_device_registers.h system_MIMXRT1062.c system_MIMXRT1062.h
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1062/utilities/: fsl_assert.c
  group component-uart
    ../../../../../components/uart/: lpuart_adapter.c uart.h
  group component-serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MIMXRT1062/arm/: startup_MIMXRT1062.S
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
    ../../../xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
