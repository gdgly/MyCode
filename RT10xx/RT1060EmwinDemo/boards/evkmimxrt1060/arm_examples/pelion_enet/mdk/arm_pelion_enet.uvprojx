# Keil uVision project arm_pelion_enet.uvprojx, settings and files
target arm_pelion_enet flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: arm_pelion_enet.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  AfterMake: python $P../../../../../middleware/arm-pelion/tools/combine_bootloader_with_app.py -b $P../mbed_bootloader.bin -a $P$L@L.bin -o $P$L@L_combined.bin -c 0x10400 -d 0x10000
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, DEBUG, CPU_MIMXRT1062DVL6A, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, SKIP_SYSCLK_INIT, FLASHIAP_APP_ROM_END_ADDR=1614807040, MBED_CONF_STORAGE_STORAGE_TYPE=TDB_INTERNAL, MBED_CONF_STORAGE_TDB_INTERNAL_INTERNAL_BASE_ADDRESS=1618935808, MBED_CONF_STORAGE_TDB_INTERNAL_INTERNAL_SIZE=65536, MBED_CLOUD_CLIENT_UPDATE_STORAGE=ARM_UCP_FLASHIAP, MBED_CONF_UPDATE_CLIENT_STORAGE_ADDRESS=1614807040, MBED_CONF_UPDATE_CLIENT_STORAGE_LOCATIONS=1, MBED_CONF_UPDATE_CLIENT_STORAGE_PAGE=256, MBED_CONF_UPDATE_CLIENT_STORAGE_SIZE=4128768, MBED_CONF_UPDATE_CLIENT_APPLICATION_DETAILS=1610678272, UPDATE_CLIENT_STORAGE_FLASHIAP, PRINTF_ADVANCED_ENABLE=0, PRINTF_FLOAT_ENABLE=0, USE_RTOS=1, __NXP_FREERTOS__, MBED_CLIENT_USER_CONFIG_FILE='\"mbed_cloud_client_user_config.h\"', MBED_CLOUD_CLIENT_USER_CONFIG_FILE='\"mbed_cloud_client_user_config.h\"', PAL_USER_DEFINED_CONFIGURATION='\"pal_config_NXP.h\"', MBEDTLS_CONFIG_FILE='\"mbedTLSConfig_NXP.h\"', MBED_CONF_NS_HAL_PAL_EVENT_LOOP_THREAD_STACK_SIZE=8000, PAL_DTLS_PEER_MIN_TIMEOUT=5000, MBED_CONF_MBED_CLOUD_CLIENT_UPDATE_DOWNLOAD_PROTOCOL=MBED_CLOUD_CLIENT_UPDATE_DOWNLOAD_PROTOCOL_COAP, COMPONENT_FLASHIAP, ARM_UC_PROFILE_MBED_CLOUD_CLIENT=1, ARM_UC_FEATURE_DELTA_PAAL=0, ATOMIC_QUEUE_USE_PAL=1, ARM_UC_FEATURE_PAL_FLASHIAP=1, MBED_CONF_MBED_CLOUD_CLIENT_EXTERNAL_SST_SUPPORT=1, PAL_USE_FILESYSTEM=0, MBED_CONF_MBED_TRACE_ENABLE=0, MBED_TRACE_MAX_LEVEL=TRACE_LEVEL_ERROR, MBED_CONF_APP_DEVELOPER_MODE=1, PLATFORM_ENABLE_BUTTON=1, PLATFORM_ENABLE_LED=1, MBED_CLOUD_APPLICATION_NONSTANDARD_ENTRYPOINT, LWIP_DHCP=1, LWIP_DNS=1, LWIP_IPV6=1, LWIP_NETIF_LINK_CALLBACK=1, LWIP_NETIF_STATUS_CALLBACK=1, LWIP_SO_SNDTIMEO=1, MBED_CLOUD_CLIENT_SUPPORT_UPDATE, PAL_SEMAPHORE_MAX_COUNT=4096, PAL_SKIP_TEST_MODULE_CRYPTO=1, PAL_SKIP_TEST_MODULE_DRBG=1, PAL_SKIP_TEST_MODULE_FILESYSTEM=1, PAL_SKIP_TEST_MODULE_INTERNALFLASH=1, PAL_SKIP_TEST_MODULE_ROT=1, PAL_SKIP_TEST_MODULE_SOTP=1, PAL_SKIP_TEST_MODULE_SST=1, PAL_SKIP_TEST_MODULE_TIME=1, PAL_SKIP_TEST_MODULE_TLS=1, PAL_SKIP_TEST_MODULE_UPDATE=1, __USE_CMSIS, RBP_TESTING, DEVICE_FLASH, SDK_DEBUGCONSOLE_UART, MBED_CONF_NANOSTACK_EVENTLOOP_EXCLUDE_HIGHRES_TIMER, MBED_CONF_NANOSTACK_EVENTLOOP_USE_PLATFORM_TICK_TIMER, MBED_CONF_MBED_CLIENT_SN_COAP_DUPLICATION_MAX_MSGS_COUNT=4, SN_COAP_REDUCE_BLOCKWISE_HEAP_FOOTPRINT=1, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS
  c misc: -fno-c++-static-destructors  -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM4F;../../../../../middleware/arm-pelion/pdmc-port/pdmc-bsp/target/nxp/mimxrt1060;..;../app;../app/source;../app/source/include;../app/source/platform;../app/source/platform/include;../../..;../../../../src/arm_examples/pelion_enet;../../../../../CMSIS/Include;../../../../../devices;../../../../../middleware/mbedtls/include;../../../../../middleware/mbedtls/port/ksdk;../../../../../middleware/arm-pelion/pdmc-port/pdmc-bsp/common;../../../../../middleware/arm-pelion/mbed-cloud-client;../../../../../middleware/arm-pelion/mbed-cloud-client/certificate-enrollment-client/source/include;../../../../../middleware/arm-pelion/mbed-cloud-client/certificate-enrollment-client/certificate-enrollment-client;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/crypto-service/crypto-service;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/crypto-service/source/include;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/factory-configurator-client/factory-configurator-client;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/factory-configurator-client/source/include;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/fcc-bundle-handler/fcc-bundle-handler;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/fcc-bundle-handler/source/include;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/fcc-output-info-handler/fcc-output-info-handler;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/ftcd-comm-base/ftcd-comm-base;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/ftcd-comm-socket/ftcd-comm-socket;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/key-config-manager/key-config-manager;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/key-config-manager;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/logger/logger;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/mbed-client-esfs/source/include;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/mbed-client-esfs/source/sotp;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/mbed-trace-helper/mbed-trace-helper;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/psa-driver/psa-driver;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/storage/storage;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/storage/source/include;../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/utils/utils;../../../../../middleware/arm-pelion/mbed-cloud-client/kvstore/conf;../../../../../middleware/arm-pelion/mbed-cloud-client/kvstore/include;../../../../../middleware/arm-pelion/mbed-cloud-client/kvstore/helpers;../../../../../middleware/arm-pelion/mbed-cloud-client/kvstore/kv_map;../../../../../middleware/arm-pelion/mbed-cloud-client/kvstore/global_api;../../../../../middleware/arm-pelion/mbed-cloud-client/kvstore/tdbstore;../../../../../middleware/arm-pelion/mbed-cloud-client/kvstore/securestore;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-c;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-c/nsdl-c;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-c/source/include;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-classic;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-classic/mbed-client-classic;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-mbed-tls;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-mbed-tls/mbed-client-mbedtls;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/source;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/source/include;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Configs/mbedTLS;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Configs/pal_config/FreeRTOS;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Configs/pal_config/NXP;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Services-API;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Platform-API;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-randlib;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-randlib/mbed-client-randlib;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-randlib/mbed-client-randlib/platform;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-cloud-client;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-coap;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-coap/mbed-coap;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-coap/source/include;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-trace;../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-trace/mbed-trace;../../../../../middleware/arm-pelion/mbed-cloud-client/nanostack-libservice;../../../../../middleware/arm-pelion/mbed-cloud-client/nanostack-libservice/mbed-client-libservice;../../../../../middleware/arm-pelion/mbed-cloud-client/nanostack-libservice/mbed-client-libservice/platform;../../../../../middleware/arm-pelion/mbed-cloud-client/ns-hal-pal;../../../../../middleware/arm-pelion/mbed-cloud-client/sal-stack-nanostack-eventloop;../../../../../middleware/arm-pelion/mbed-cloud-client/sal-stack-nanostack-eventloop/nanostack-event-loop;../../../../../middleware/arm-pelion/mbed-cloud-client/sal-stack-nanostack-eventloop/nanostack-event-loop/platform;../../../../../middleware/arm-pelion/mbed-cloud-client/sal-stack-nanostack-eventloop/source;../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/logger/logger;../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/helpers/helpers;../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/mem/mem;../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/platform/platform;../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/sda-bundle-parser/sda-bundle-parser;../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/secure-device-access/secure-device-access;../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/secure-device-access/source/include;../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/sda-cose/sda-cose;../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/cose-c/cose-c;../../../../../middleware/arm-pelion/mbed-cloud-client/source;../../../../../middleware/arm-pelion/mbed-cloud-client/source/include;../../../../../middleware/arm-pelion/mbed-cloud-client/tinycbor/src;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/delta-tool-internal/include;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/atomic-queue;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/atomic-queue/atomic-queue;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/atomic-queue/source;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/common;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/common/update-client-common;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/control-center;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/control-center/update-client-control-center;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/device-identity;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/device-identity/pal4life-device-identity;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/firmware-manager/update-client-firmware-manager;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/firmware-manager;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/lwm2m-mbed;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/lwm2m-mbed/update-client-lwm2m;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/manifest-manager;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/manifest-manager/update-client-manifest-manager;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/manifest-manager/source;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/metadata-header;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/metadata-header/update-client-metadata-header;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/monitor;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/monitor/update-client-monitor;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/paal;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/paal/update-client-paal;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/pal-blockdevice;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/pal-blockdevice/update-client-pal-blockdevice;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/pal-flashiap;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/pal-flashiap/update-client-pal-flashiap;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/pal-flashiap-mcuboot;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/source-manager/update-client-source-manager;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/source-manager;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/source;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/source-http;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/source;../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub;../../../../../rtos/freertos/freertos_kernel/include;../../../../../components/phy/mdio/enet;../../../../../components/phy/device/phyksz8081;../../../../../devices/MIMXRT1062/drivers;../../../../../middleware/lwip/port;../../../../../middleware/lwip/src;../../../../../middleware/lwip/src/include;../../../../../devices/MIMXRT1062/utilities/str;../../../../../devices/MIMXRT1062/utilities/debug_console;../../../../../devices/MIMXRT1062;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../devices/MIMXRT1062/xip;../../../xip;../../../../../components/phy;../../../../../devices/MIMXRT1062/utilities
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..;../../..
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: --remove --predefine="-DMBED_APP_START=0x60010400" --predefine="-DMBED_APP_SIZE=0x3EFC00" --predefine="-D__heap_size__=0xC0000" --predefine="-D__stack_size__=0x2000"
  group arm-pelion-pdmc-port-pdmc-bsp-common
    ../../../../../middleware/arm-pelion/pdmc-port/pdmc-bsp/common/: flash_api.c FlashIAP.cpp FlashIAP.h flash_api.h port_storage.h
  group arm-pelion-pdmc-port-pdmc-bsp-target-nxp-mimxrt1060
    ../../../../../middleware/arm-pelion/pdmc-port/pdmc-bsp/target/nxp/mimxrt1060/: flexspi_nor_flash_ops.c rt1060_flexspi_storage.c flexspi_nor_flash_ops.h
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Source-Port-Reference-Impl-OS_Specific-NXP-Board_Specific-TARGET_RT1060
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/OS_Specific/NXP/Board_Specific/TARGET_RT1060/: pal_plat_RT1060.c
  group source
    ../: rtos_startup.c
    ../app/: main.cpp
  group source-app
    ../app/: mbed_cloud_dev_credentials.c update_ui_example.cpp update_default_resources.c
    ../app/source/: resource.cpp memory_tests.cpp certificate_enrollment_user_cb.cpp blinky.cpp application_init.cpp app_platform_setup.c
  group include
    ../app/: update_ui_example.h
    ../app/source/: resource.h simplem2mclient.h memory_tests.h certificate_enrollment_user_cb.h blinky.h application_init.h
    ../app/source/include/: app_platform_setup.h
    ../app/source/platform/NXP/: mcc_common_serial.h
    ../app/source/platform/include/: mcc_common_button_and_led.h mcc_common_setup.h
  group config
    ../app/: mbed_cloud_client_user_config.h pal_config_NXP.h
    ../app/source/platform/include/: mcc_common_config.h
    ../: lwipopts.h FreeRTOSConfig.h
  group source-app-platform
    ../app/source/platform/NXP/: mcc_common_setup.c mcc_common_button_and_led.c event_platform.c
    ../app/source/platform/: pal_plat_rot_insecure.c
  group arm-pelion-tools
    ../../../../../middleware/arm-pelion/tools/: combine_bootloader_with_app.py
  group evkmimxrt1060-arm_examples-pelion_enet
    ../: mbed_bootloader.bin
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h dcd.c dcd.h
  group doc
    ../: readme.txt
  group mdio
    ../../../../../components/phy/mdio/enet/: fsl_enet_mdio.c fsl_enet_mdio.h
    ../../../../../components/phy/: fsl_mdio.h
  group phy
    ../../../../../components/phy/device/phyksz8081/: fsl_phyksz8081.c fsl_phyksz8081.h
    ../../../../../components/phy/: fsl_phy.h
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_trng.c fsl_trng.h fsl_dcp.c fsl_dcp.h fsl_cache.c fsl_cache.h fsl_flexspi.c fsl_flexspi.h fsl_pit.c fsl_pit.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_lpuart.c fsl_lpuart.h fsl_iomuxc.h fsl_gpio.c fsl_gpio.h fsl_enet.c fsl_enet.h
  group lwip-port-arch
    ../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip-port
    ../../../../../middleware/lwip/port/: sys_arch.c enet_ethernetif.c enet_ethernetif.h enet_ethernetif_kinetis.c enet_ethernetif_priv.h
  group lwip-src-api
    ../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-src-core
    ../../../../../middleware/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip-src-core-ipv4
    ../../../../../middleware/lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip-src-core-ipv6
    ../../../../../middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip-src-include-compat-posix-arpa
    ../../../../../middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lwip-src-include-compat-posix-net
    ../../../../../middleware/lwip/src/include/compat/posix/net/: if.h
  group lwip-src-include-compat-posix
    ../../../../../middleware/lwip/src/include/compat/posix/: netdb.h
  group lwip-src-include-compat-posix-sys
    ../../../../../middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lwip-src-include-compat-stdc
    ../../../../../middleware/lwip/src/include/compat/stdc/: errno.h
  group lwip-src-include-lwip
    ../../../../../middleware/lwip/src/include/lwip/: acd.h altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lwip-src-include-lwip-priv
    ../../../../../middleware/lwip/src/include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h memp_std.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
  group lwip-src-include-lwip-prot
    ../../../../../middleware/lwip/src/include/lwip/prot/: acd.h autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip-src-include-netif
    ../../../../../middleware/lwip/src/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group lwip-src-include-netif-ppp
    ../../../../../middleware/lwip/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip-src-include-netif-ppp-polarssl
    ../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip-src-netif
    ../../../../../middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip-src-netif-ppp
    ../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1062/utilities/: fsl_assert.c
  group freertos-freertos_kernel-portable-MemMang
    ../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_3.c ReadMe.url
  group mbedtls-include-mbedtls
    ../../../../../middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls-library
    ../../../../../middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls-port-ksdk
    ../../../../../middleware/mbedtls/port/ksdk/: aes_alt.c aes_alt.h des_alt.c des_alt.h ecp_alt.c ecp_alt.h ecp_alt_ksdk.c ecp_curves_alt.c ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h
  group arm-pelion
    ../../../../../middleware/arm-pelion/: ChangeLogKSDK.txt
  group arm-pelion-mbed-cloud-client
    ../../../../../middleware/arm-pelion/mbed-cloud-client/: CHANGELOG.md CONTRIBUTING.md LICENSE README.md
  group arm-pelion-mbed-cloud-client-certificate-enrollment-client-certificate-enrollment-client
    ../../../../../middleware/arm-pelion/mbed-cloud-client/certificate-enrollment-client/certificate-enrollment-client/: CertificateEnrollmentClient.h ce_defs.h ce_status.h
  group arm-pelion-mbed-cloud-client-certificate-enrollment-client-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/certificate-enrollment-client/source/: CertificateEnrollmentClient.cpp CertificateEnrollmentClientCommon.cpp CertificateRenewalData.cpp ce_safe_renewal_internal.c ce_tlv.c certificate_enrollment.c
  group arm-pelion-mbed-cloud-client-certificate-enrollment-client-source-include
    ../../../../../middleware/arm-pelion/mbed-cloud-client/certificate-enrollment-client/source/include/: CertificateEnrollmentClientCommon.h CertificateRenewalData.h ce_internal.h ce_tlv.h certificate_enrollment.h
  group arm-pelion-mbed-cloud-client-factory-configurator-client-crypto-service-crypto-service
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/crypto-service/crypto-service/: cs_der_certs.h cs_der_keys_and_csrs.h cs_hash.h
  group arm-pelion-mbed-cloud-client-factory-configurator-client-crypto-service-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/crypto-service/source/: cs_der_certs.c cs_der_keys_and_csrs.c cs_hash.c cs_utils.c
  group arm-pelion-mbed-cloud-client-factory-configurator-client-crypto-service-source-include
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/crypto-service/source/include/: cs_utils.h
  group arm-pelion-mbed-cloud-client-factory-configurator-client-factory-configurator-client-factory-configurator-client
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/factory-configurator-client/factory-configurator-client/: factory_configurator_client.h fcc_defs.h fcc_status.h
  group arm-pelion-mbed-cloud-client-factory-configurator-client-factory-configurator-client-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/factory-configurator-client/source/: factory_configurator_client.c fcc_dev_flow.c fcc_utils.c fcc_verification.c
  group arm-pelion-mbed-cloud-client-factory-configurator-client-factory-configurator-client-source-include
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/factory-configurator-client/source/include/: fcc_bundle_fields.h fcc_utils.h fcc_verification.h
  group arm-pelion-mbed-cloud-client-factory-configurator-client-fcc-bundle-handler-fcc-bundle-handler
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/fcc-bundle-handler/fcc-bundle-handler/: fcc_bundle_handler.h
  group arm-pelion-mbed-cloud-client-factory-configurator-client-fcc-bundle-handler-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/fcc-bundle-handler/source/: fcc_bundle_certificate_utils.c fcc_bundle_common_utils.c fcc_bundle_config_params_utils.c fcc_bundle_csr_utils.c fcc_bundle_handler.c fcc_bundle_key_utils.c
  group arm-pelion-mbed-cloud-client-factory-configurator-client-fcc-bundle-handler-source-include
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/fcc-bundle-handler/source/include/: fcc_bundle_utils.h
  group arm-pelion-mbed-cloud-client-factory-configurator-client-fcc-output-info-handler-fcc-output-info-handler
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/fcc-output-info-handler/fcc-output-info-handler/: fcc_output_info_handler.h fcc_output_info_handler_defines.h
  group arm-pelion-mbed-cloud-client-factory-configurator-client-fcc-output-info-handler-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/fcc-output-info-handler/source/: fcc_output_info_handler.c
  group arm-pelion-mbed-cloud-client-factory-configurator-client-ftcd-comm-base-ftcd-comm-base
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/ftcd-comm-base/ftcd-comm-base/: ftcd_comm_base.h
  group arm-pelion-mbed-cloud-client-factory-configurator-client-ftcd-comm-base-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/ftcd-comm-base/source/: ftcd_comm_base.cpp
  group arm-pelion-mbed-cloud-client-factory-configurator-client-ftcd-comm-socket-ftcd-comm-socket
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/ftcd-comm-socket/ftcd-comm-socket/: ftcd_comm_socket.h
  group arm-pelion-mbed-cloud-client-factory-configurator-client-ftcd-comm-socket-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/ftcd-comm-socket/source/: ftcd_comm_socket.cpp
  group arm-pelion-mbed-cloud-client-factory-configurator-client-key-config-manager-key-config-manager
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/key-config-manager/key-config-manager/: kcm_defs.h kcm_status.h key_config_manager.h
  group arm-pelion-mbed-cloud-client-factory-configurator-client-key-config-manager-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/key-config-manager/source/: key_config_manager.c
  group arm-pelion-mbed-cloud-client-factory-configurator-client-logger-logger
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/logger/logger/: pv_log.h
  group arm-pelion-mbed-cloud-client-factory-configurator-client-mbed-client-esfs-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/mbed-client-esfs/source/: esfs_file_name.c esfs_performance.c
  group arm-pelion-mbed-cloud-client-factory-configurator-client-mbed-client-esfs-source-include
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/mbed-client-esfs/source/include/: esfs.h esfs_file_name.h esfs_performance.h sotp.h
  group arm-pelion-mbed-cloud-client-factory-configurator-client-mbed-client-esfs-source-sotp
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/mbed-client-esfs/source/sotp/: sotp.c sotp_int.h sotp_log.c sotp_log.h sotp_no_sotp.c sotp_shared_lock.c sotp_shared_lock.h
  group arm-pelion-mbed-cloud-client-factory-configurator-client-mbed-trace-helper-mbed-trace-helper
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/mbed-trace-helper/mbed-trace-helper/: mbed-trace-helper.h
  group arm-pelion-mbed-cloud-client-factory-configurator-client-mbed-trace-helper-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/mbed-trace-helper/source/: mbed-trace-helper.c
  group arm-pelion-mbed-cloud-client-factory-configurator-client-psa-driver-psa-driver
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/psa-driver/psa-driver/: psa_driver.h psa_driver_dispatcher.h
  group arm-pelion-mbed-cloud-client-factory-configurator-client-psa-driver-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/psa-driver/source/: psa_driver_common.c psa_driver_crypto.c psa_driver_dispatcher.c psa_driver_ps.c
  group arm-pelion-mbed-cloud-client-factory-configurator-client-storage-source-include
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/storage/source/include/: key_slot_allocator.h key_slot_allocator_internal.h se_slot_manager.h se_slot_manager_defs.h storage_internal.h storage_pelion_sst.h
  group arm-pelion-mbed-cloud-client-factory-configurator-client-storage-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/storage/source/: key_slot_allocator.c storage_common.c storage_non_psa.c storage_pal_sst.c storage_pelion_sst.c storage_psa.c
  group arm-pelion-mbed-cloud-client-factory-configurator-client-storage-storage
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/storage/storage/: storage_kcm.h
  group arm-pelion-mbed-cloud-client-factory-configurator-client-utils-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/utils/source/: common_utils.c fcc_stats.c fcc_time_profiling.c general_utils.c pv_error_handling.c
  group arm-pelion-mbed-cloud-client-factory-configurator-client-utils-utils
    ../../../../../middleware/arm-pelion/mbed-cloud-client/factory-configurator-client/utils/utils/: common_utils.h fcc_malloc.h fcc_stats.h fcc_time_profiling.h general_utils.h mbed_stats_helper.h pv_endian.h pv_error_handling.h pv_macros.h
  group arm-pelion-mbed-cloud-client-kvstore-conf
    ../../../../../middleware/arm-pelion/mbed-cloud-client/kvstore/conf/: kv_config.cpp kv_config.h
  group arm-pelion-mbed-cloud-client-kvstore-global_api
    ../../../../../middleware/arm-pelion/mbed-cloud-client/kvstore/global_api/: kvstore_global_api.cpp kvstore_global_api.h
  group arm-pelion-mbed-cloud-client-kvstore-helpers
    ../../../../../middleware/arm-pelion/mbed-cloud-client/kvstore/helpers/: BlockDevice.h BufferedBlockDevice.cpp BufferedBlockDevice.h DeviceKey.cpp DeviceKey.h ExternalBlockDevice.h FlashIAP.h FlashIAPBlockDevice.cpp FlashIAPBlockDevice.h FlashSimBlockDevice.cpp FlashSimBlockDevice.h NonCopyable.h SPIFBlockDevice.h SingletonPtr.h SlicingBlockDevice.cpp SlicingBlockDevice.h pal_plat_rot.cpp
  group arm-pelion-mbed-cloud-client-kvstore-include
    ../../../../../middleware/arm-pelion/mbed-cloud-client/kvstore/include/: KVStore.h
  group arm-pelion-mbed-cloud-client-kvstore-kv_map
    ../../../../../middleware/arm-pelion/mbed-cloud-client/kvstore/kv_map/: KVMap.cpp KVMap.h
  group arm-pelion-mbed-cloud-client-kvstore-securestore
    ../../../../../middleware/arm-pelion/mbed-cloud-client/kvstore/securestore/: SecureStore.cpp SecureStore.h
  group arm-pelion-mbed-cloud-client-kvstore-tdbstore
    ../../../../../middleware/arm-pelion/mbed-cloud-client/kvstore/tdbstore/: TDBStore.cpp TDBStore.h
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Configs-mbedTLS
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Configs/mbedTLS/: mbedTLSConfig_ARIA_mbedOS.h mbedTLSConfig_FreeRTOS.h mbedTLSConfig_Linux.h mbedTLSConfig_NXP.h mbedTLSConfig_Renesas_EK_RA6M3.h mbedTLSConfig_SXOS_SW_TRNG.h mbedTLSConfig_mbedOS.h mbedTLSConfig_mbedOS_SW_TRNG.h mbedTLSConfig_mbedOS_SW_TRNG_PSA.h mbedtls_config_RTX.h
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Configs-pal_config-FreeRTOS
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Configs/pal_config/FreeRTOS/: FreeRTOS_default.h
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Configs-pal_config-NXP
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Configs/pal_config/NXP/: NXP_default.h
  group arm-pelion-mbed-cloud-client-mbed-client-pal
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/: LICENSE
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Source-PAL-Impl-Modules-Crypto
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Modules/Crypto/: pal_Crypto.c
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Source-PAL-Impl-Modules-DRBG
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Modules/DRBG/: pal_drbg.c
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Source-PAL-Impl-Modules-Entropy
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Modules/Entropy/: pal_entropy.c
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Source-PAL-Impl-Modules-Networking
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Modules/Networking/: pal_network.c
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Source-PAL-Impl-Modules-ROT
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Modules/ROT/: pal_rot.c
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Source-PAL-Impl-Modules-RTOS
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Modules/RTOS/: pal_rtos.c
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Source-PAL-Impl-Modules-Storage-Flash
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Modules/Storage/Flash/: pal_internalFlash.c
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Source-PAL-Impl-Modules-TLS
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Modules/TLS/: pal_TLS.c
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Source-PAL-Impl-Modules-Time
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Modules/Time/: pal_time.c
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Source-PAL-Impl-Services-API
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/Services-API/: pal.h pal_Crypto.h pal_TLS.h pal_configuration.h pal_drbg.h pal_entropy.h pal_errors.h pal_fileSystem.h pal_internalFlash.h pal_macros.h pal_network.h pal_rot.h pal_rtos.h pal_sst.h pal_time.h pal_types.h pal_update.h
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Source-PAL-Impl
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/PAL-Impl/: pal_init.c
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Source-Port-Platform-API
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Platform-API/: pal_plat_Crypto.h pal_plat_TLS.h pal_plat_drbg.h pal_plat_drbg_noise.h pal_plat_entropy.h pal_plat_fileSystem.h pal_plat_internalFlash.h pal_plat_network.h pal_plat_rot.h pal_plat_rtos.h pal_plat_time.h pal_plat_update.h
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Source-Port-Reference-Impl-Generic-DRBG-PSA
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/DRBG/PSA/: pal_plat_drbg_psa.c
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Source-Port-Reference-Impl-Generic-DRBG-SOTP
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/DRBG/SOTP/: pal_plat_drbg_sotp.c
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Source-Port-Reference-Impl-Generic-DRBG
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/DRBG/: pal_plat_drbg_noise.c
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Source-Port-Reference-Impl-Generic-Entropy-PSA
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/Entropy/PSA/: pal_plat_entropy_psa.c
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Source-Port-Reference-Impl-Generic-Entropy-SOTP
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/Entropy/SOTP/: pal_plat_entropy_sotp.c
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Source-Port-Reference-Impl-Generic-ROT-External
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/ROT/External/: pal_plat_rot_hw.c
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Source-Port-Reference-Impl-Generic-ROT-PSA
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/ROT/PSA/: pal_plat_rot_psa.c
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Source-Port-Reference-Impl-Generic-ROT-SOTP
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/ROT/SOTP/: pal_plat_rot_sotp.c
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Source-Port-Reference-Impl-Generic-SST-kvstore_impl
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/SST/kvstore_impl/: pal_plat_sst_impl.c
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Source-Port-Reference-Impl-Generic-Storage-FileSystem
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/Storage/FileSystem/: pal_plat_fileSystem_FsOverRam.c
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Source-Port-Reference-Impl-Generic-Storage-Flash
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/Storage/Flash/: pal_plat_internalFlash_FlashOverFilesystem.c
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Source-Port-Reference-Impl-Generic-Time
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Generic/Time/: pal_plat_time.c
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Source-Port-Reference-Impl-Lib_Specific-mbedTLS-Crypto
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Lib_Specific/mbedTLS/Crypto/: pal_plat_Crypto.c
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Source-Port-Reference-Impl-Lib_Specific-mbedTLS-DRBG
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Lib_Specific/mbedTLS/DRBG/: pal_plat_drbg_w_entropy_sources.c
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Source-Port-Reference-Impl-Lib_Specific-mbedTLS-TLS
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/Lib_Specific/mbedTLS/TLS/: pal_plat_TLS.c
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Source-Port-Reference-Impl-OS_Specific-NXP-Networking-LWIP
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/OS_Specific/NXP/Networking/LWIP/: pal_plat_network.c
  group arm-pelion-mbed-cloud-client-mbed-client-pal-Source-Port-Reference-Impl-OS_Specific-NXP-RTOS
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-pal/Source/Port/Reference-Impl/OS_Specific/NXP/RTOS/: pal_plat_rtos.c
  group arm-pelion-mbed-cloud-client-mbed-client-randlib
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-randlib/: LICENSE apache-2.0.txt
  group arm-pelion-mbed-cloud-client-mbed-client-randlib-mbed-client-randlib-platform
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-randlib/mbed-client-randlib/platform/: arm_hal_random.h
  group arm-pelion-mbed-cloud-client-mbed-client-randlib-mbed-client-randlib
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-randlib/mbed-client-randlib/: randLIB.h
  group arm-pelion-mbed-cloud-client-mbed-client-randlib-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client-randlib/source/: randLIB.c
  group arm-pelion-mbed-cloud-client-mbed-client
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/: LICENSE
  group arm-pelion-mbed-cloud-client-mbed-client-mbed-client-c
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-c/: LICENSE README.txt apache-2.0.txt
  group arm-pelion-mbed-cloud-client-mbed-client-mbed-client-c-nsdl-c
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-c/nsdl-c/: sn_client_config.h sn_nsdl.h sn_nsdl_lib.h
  group arm-pelion-mbed-cloud-client-mbed-client-mbed-client-c-source-include
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-c/source/include/: sn_grs.h
  group arm-pelion-mbed-cloud-client-mbed-client-mbed-client-c-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-c/source/: sn_grs.c sn_nsdl.c
  group arm-pelion-mbed-cloud-client-mbed-client-mbed-client-classic
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-classic/: LICENSE
  group arm-pelion-mbed-cloud-client-mbed-client-mbed-client-classic-mbed-client-classic
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-classic/mbed-client-classic/: m2mconnectionhandlerpimpl.h m2mtimerpimpl.h
  group arm-pelion-mbed-cloud-client-mbed-client-mbed-client-classic-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-classic/source/: m2mconnectionhandler.cpp m2mconnectionhandlerpimpl.cpp m2mtimer.cpp m2mtimerpimpl.cpp
  group arm-pelion-mbed-cloud-client-mbed-client-mbed-client-mbed-tls
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-mbed-tls/: LICENSE apache-2.0.txt
  group arm-pelion-mbed-cloud-client-mbed-client-mbed-client-mbed-tls-mbed-client-mbedtls
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-mbed-tls/mbed-client-mbedtls/: m2mconnectionsecuritypimpl.h
  group arm-pelion-mbed-cloud-client-mbed-client-mbed-client-mbed-tls-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client-mbed-tls/source/: m2mconnectionsecurity.cpp m2mconnectionsecuritypimpl.cpp
  group arm-pelion-mbed-cloud-client-mbed-client-mbed-client
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/mbed-client/: coap_response.h functionpointer.h m2mbase.h m2mblockmessage.h m2mconfig.h m2mconnectionhandler.h m2mconnectionobserver.h m2mconnectionsecurity.h m2mconstants.h m2mdevice.h m2mendpoint.h m2mfirmware.h m2minterface.h m2minterfacefactory.h m2minterfaceobserver.h m2mobject.h m2mobjectinstance.h m2mobservationhandler.h m2mreportobserver.h m2mresource.h m2mresourcebase.h m2mresourceinstance.h m2msecurity.h m2mserver.h m2mstring.h m2mstringbuffer.h m2mstringbufferbase.h m2mtimer.h m2mtimerobserver.h m2mvector.h uriqueryparser.h
  group arm-pelion-mbed-cloud-client-mbed-client-source-include
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/source/include/: eventdata.h m2mcallbackstorage.h m2minterfaceimpl.h m2mnotificationhandler.h m2mnsdlinterface.h m2mnsdlobserver.h m2mreporthandler.h m2mtlvdeserializer.h m2mtlvserializer.h nsdlaccesshelper.h nsdllinker.h smartpointer.h
  group arm-pelion-mbed-cloud-client-mbed-client-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-client/source/: m2mbase.cpp m2mblockmessage.cpp m2mcallbackstorage.cpp m2mdevice.cpp m2mendpoint.cpp m2mfirmware.cpp m2minterfacefactory.cpp m2minterfaceimpl.cpp m2mnotificationhandler.cpp m2mnsdlinterface.cpp m2mobject.cpp m2mobjectinstance.cpp m2mreporthandler.cpp m2mresource.cpp m2mresourcebase.cpp m2mresourceinstance.cpp m2msecurity.cpp m2mserver.cpp m2mstring.cpp m2mstringbufferbase.cpp m2mtlvdeserializer.cpp m2mtlvserializer.cpp nsdlaccesshelper.cpp uriqueryparser.c
  group arm-pelion-mbed-cloud-client-mbed-cloud-client
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-cloud-client/: MbedCloudClient.h MbedCloudClientConfig.h MbedCloudClientConfigCheck.h SimpleM2MResource.h est_defs.h
  group arm-pelion-mbed-cloud-client-mbed-coap
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-coap/: LICENSE README.txt apache-2.0.txt
  group arm-pelion-mbed-cloud-client-mbed-coap-mbed-coap
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-coap/mbed-coap/: sn_coap_header.h sn_coap_protocol.h sn_config.h
  group arm-pelion-mbed-cloud-client-mbed-coap-source-include
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-coap/source/include/: sn_coap_header_internal.h sn_coap_protocol_internal.h
  group arm-pelion-mbed-cloud-client-mbed-coap-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-coap/source/: sn_coap_builder.c sn_coap_header_check.c sn_coap_parser.c sn_coap_protocol.c
  group arm-pelion-mbed-cloud-client-mbed-trace
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-trace/: LICENSE
  group arm-pelion-mbed-cloud-client-mbed-trace-mbed-trace
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-trace/mbed-trace/: mbed_trace.h
  group arm-pelion-mbed-cloud-client-mbed-trace-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/mbed-trace/source/: mbed_trace.c
  group arm-pelion-mbed-cloud-client-nanostack-libservice
    ../../../../../middleware/arm-pelion/mbed-cloud-client/nanostack-libservice/: LICENSE apache-2.0.txt
  group arm-pelion-mbed-cloud-client-nanostack-libservice-mbed-client-libservice
    ../../../../../middleware/arm-pelion/mbed-cloud-client/nanostack-libservice/mbed-client-libservice/: common_functions.h ip4string.h ip6string.h ip_fsc.h ns_list.h ns_nvm_helper.h ns_trace.h ns_types.h nsdynmemLIB.h
  group arm-pelion-mbed-cloud-client-nanostack-libservice-mbed-client-libservice-platform
    ../../../../../middleware/arm-pelion/mbed-cloud-client/nanostack-libservice/mbed-client-libservice/platform/: arm_hal_interrupt.h arm_hal_nvm.h
  group arm-pelion-mbed-cloud-client-nanostack-libservice-source-libBits
    ../../../../../middleware/arm-pelion/mbed-cloud-client/nanostack-libservice/source/libBits/: common_functions.c
  group arm-pelion-mbed-cloud-client-nanostack-libservice-source-libList
    ../../../../../middleware/arm-pelion/mbed-cloud-client/nanostack-libservice/source/libList/: ns_list.c
  group arm-pelion-mbed-cloud-client-nanostack-libservice-source-libip6string
    ../../../../../middleware/arm-pelion/mbed-cloud-client/nanostack-libservice/source/libip6string/: ip6tos.c
  group arm-pelion-mbed-cloud-client-nanostack-libservice-source-nsdynmemLIB
    ../../../../../middleware/arm-pelion/mbed-cloud-client/nanostack-libservice/source/nsdynmemLIB/: nsdynmemLIB.c
  group arm-pelion-mbed-cloud-client-ns-hal-pal
    ../../../../../middleware/arm-pelion/mbed-cloud-client/ns-hal-pal/: arm_hal_interrupt.c arm_hal_interrupt_private.h arm_hal_random.c arm_hal_timer.cpp ns_event_loop.c ns_event_loop.h ns_hal_init.c ns_hal_init.h
  group arm-pelion-mbed-cloud-client-sal-stack-nanostack-eventloop
    ../../../../../middleware/arm-pelion/mbed-cloud-client/sal-stack-nanostack-eventloop/: LICENSE apache-2.0.txt
  group arm-pelion-mbed-cloud-client-sal-stack-nanostack-eventloop-nanostack-event-loop
    ../../../../../middleware/arm-pelion/mbed-cloud-client/sal-stack-nanostack-eventloop/nanostack-event-loop/: eventOS_callback_timer.h eventOS_event.h eventOS_event_timer.h eventOS_scheduler.h
  group arm-pelion-mbed-cloud-client-sal-stack-nanostack-eventloop-nanostack-event-loop-platform
    ../../../../../middleware/arm-pelion/mbed-cloud-client/sal-stack-nanostack-eventloop/nanostack-event-loop/platform/: arm_hal_timer.h eventloop_config.h
  group arm-pelion-mbed-cloud-client-sal-stack-nanostack-eventloop-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/sal-stack-nanostack-eventloop/source/: event.c event.h ns_timeout.c ns_timer.c ns_timer.h system_timer.c timer_sys.h
  group arm-pelion-mbed-cloud-client-secure-device-access-client-cose-c
    ../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/cose-c/: LICENSE
  group arm-pelion-mbed-cloud-client-secure-device-access-client-cose-c-cose-c
    ../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/cose-c/cose-c/: configure.h cose.h cose_int.h crypto_cose.h
  group arm-pelion-mbed-cloud-client-secure-device-access-client-cose-c-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/cose-c/source/: Cose.c Encrypt.c Encrypt0.c MacMessage.c MacMessage0.c Recipient.c Sign.c Sign0.c SignerInfo.c bcrypt.c cbor.c mbedtls.c mbedtls_tiny_cbor.c
  group arm-pelion-mbed-cloud-client-secure-device-access-client-helpers-helpers
    ../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/helpers/helpers/: sda_data_token.h sda_endian.h sda_macros.h
  group arm-pelion-mbed-cloud-client-secure-device-access-client-helpers-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/helpers/source/: sda_data_token.c
  group arm-pelion-mbed-cloud-client-secure-device-access-client-logger-logger
    ../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/logger/logger/: sda_error_handling.h sda_log.h
  group arm-pelion-mbed-cloud-client-secure-device-access-client-mem-mem
    ../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/mem/mem/: sda_malloc.h
  group arm-pelion-mbed-cloud-client-secure-device-access-client-mem-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/mem/source/: sda_malloc.c
  group arm-pelion-mbed-cloud-client-secure-device-access-client-sda-bundle-parser-sda-bundle-parser
    ../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/sda-bundle-parser/sda-bundle-parser/: sda_bundle_parser.h
  group arm-pelion-mbed-cloud-client-secure-device-access-client-sda-bundle-parser-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/sda-bundle-parser/source/: sda_bundle_parser.c
  group arm-pelion-mbed-cloud-client-secure-device-access-client-sda-cose-sda-cose
    ../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/sda-cose/sda-cose/: sda_cose.h
  group arm-pelion-mbed-cloud-client-secure-device-access-client-sda-cose-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/sda-cose/source/: sda_cose.c
  group arm-pelion-mbed-cloud-client-secure-device-access-client-secure-device-access-secure-device-access
    ../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/secure-device-access/secure-device-access/: sda_status.h secure_device_access.h
  group arm-pelion-mbed-cloud-client-secure-device-access-client-secure-device-access-source-include
    ../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/secure-device-access/source/include/: sda_error_translation.h sda_internal_defs.h sda_nonce_mgr.h sda_status_internal.h sda_trust_anchor.h sda_verification.h
  group arm-pelion-mbed-cloud-client-secure-device-access-client-secure-device-access-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/secure-device-access-client/secure-device-access/source/: sda_error_translation.c sda_nonce_mgr.c sda_trust_anchor.c sda_verification.c secure_device_access.c
  group arm-pelion-mbed-cloud-client-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/source/: CertificateParser.c CloudClientStorage.c ConnectorClient.cpp EstClient.cpp MbedCloudClient.cpp ServiceClient.cpp SimpleM2MResource.cpp UpdateClient.cpp
  group arm-pelion-mbed-cloud-client-source-include
    ../../../../../middleware/arm-pelion/mbed-cloud-client/source/include/: CertificateParser.h CloudClientStorage.h ConnectorClient.h EstClient.h ServiceClient.h UpdateClient.h UpdateClientResources.h
  group arm-pelion-mbed-cloud-client-tinycbor
    ../../../../../middleware/arm-pelion/mbed-cloud-client/tinycbor/: LICENSE
  group arm-pelion-mbed-cloud-client-tinycbor-src
    ../../../../../middleware/arm-pelion/mbed-cloud-client/tinycbor/src/: cborencoder.c cborencoder_close_container_checked.c cborerrorstrings.c cborinternal_p.h cborjson.h cborparser.c cborparser_dup_string.c cborpretty.c cborvalidation.c compilersupport_p.h tinycbor-version.h tinycbor.h utf8_p.h
  group arm-pelion-mbed-cloud-client-update-client-hub
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/: LICENSE
  group arm-pelion-mbed-cloud-client-update-client-hub-delta-tool-internal-include
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/delta-tool-internal/include/: bspatch.h bspatch_private.h lz4.h varint.h
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-atomic-queue
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/atomic-queue/: LICENSE
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-atomic-queue-atomic-queue
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/atomic-queue/atomic-queue/: atomic-queue.h
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-atomic-queue-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/atomic-queue/source/: aq_critical.h atomic-cm3.c atomic-queue.c atomic.c atomic.h critical-pal.c critical-posix.c critical.c
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-common
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/common/: LICENSE
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-common-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/common/source/: arm_uc_crypto_mbedtls.c arm_uc_crypto_pal.c arm_uc_error.c arm_uc_hw_plat.c arm_uc_scheduler.c arm_uc_test_rot.c arm_uc_utilities.c
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-common-update-client-common
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/common/update-client-common/: arm_uc_common.h arm_uc_config.h arm_uc_crypto.h arm_uc_error.h arm_uc_hw_plat.h arm_uc_public.h arm_uc_scheduler.h arm_uc_trace.h arm_uc_types.h arm_uc_types_internal.h arm_uc_utilities.h
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-control-center
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/control-center/: LICENSE
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-control-center-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/control-center/source/: arm_uc_certificate.c arm_uc_certificate_kcm_api.c arm_uc_certificate_raw_api.c arm_uc_control_center.c arm_uc_pre_shared_key.c
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-control-center-update-client-control-center
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/control-center/update-client-control-center/: arm_uc_certificate.h arm_uc_control_center.h arm_uc_pre_shared_key.h
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-device-identity
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/device-identity/: LICENSE
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-device-identity-pal4life-device-identity
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/device-identity/pal4life-device-identity/: pal_device_identity.h
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-device-identity-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/device-identity/source/: arm_uc_device_identity.c arm_uc_device_identity_kcm.c arm_uc_device_identity_nvstore.c arm_uc_device_identity_raw.c
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-firmware-manager
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/firmware-manager/: LICENSE
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-firmware-manager-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/firmware-manager/source/: arm_uc_firmware_manager.c
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-firmware-manager-update-client-firmware-manager
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/firmware-manager/update-client-firmware-manager/: arm_uc_firmware_manager.h
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-lwm2m-mbed
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/lwm2m-mbed/: LICENSE
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-lwm2m-mbed-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/lwm2m-mbed/source/: DeviceMetadataResource.cpp FirmwareUpdateResource.cpp device_metadata.c firmware_update.c lwm2m-control.cpp lwm2m-monitor.cpp lwm2m-source.cpp update-lwm2m-mbed-apis.c update-lwm2m-mbed-apis.h update_lwm2m_monitor.c
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-lwm2m-mbed-update-client-lwm2m
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/lwm2m-mbed/update-client-lwm2m/: DeviceMetadataResource.h FirmwareUpdateResource.h device_metadata.h firmware_update.h lwm2m-control.h lwm2m-monitor.h lwm2m-source.h update_lwm2m_monitor.h
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-manifest-manager
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/manifest-manager/: LICENSE
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-manifest-manager-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/manifest-manager/source/: arm_uc_mmCommon.c arm_uc_mmCommon.h arm_uc_mmConfig.h arm_uc_mmCryptoUtils.c arm_uc_mmCryptoUtils.h arm_uc_mmDerManifestAccessors.c arm_uc_mmDerManifestAccessors.h arm_uc_mmDerManifestParser.c arm_uc_mmDerManifestParser.h arm_uc_mmFSMHelper.h arm_uc_mmFetchFirmwareInfo.c arm_uc_mmFetchFirmwareInfo.h arm_uc_mmGetLatestTimestamp.c arm_uc_mmGetLatestTimestamp.h arm_uc_mmInit.c arm_uc_mmInit.h arm_uc_mmInsertManifest.c arm_uc_mmInsertManifest.h arm_uc_mmStateSelector.c arm_uc_mmStateSelector.h manifest-manager-api.c
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-manifest-manager-update-client-manifest-manager
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/manifest-manager/update-client-manifest-manager/: arm-pal-kv.h update-client-manifest-manager-context.h update-client-manifest-manager.h update-client-manifest-types.h
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-metadata-header-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/metadata-header/source/: arm_uc_buffer_utilities.c arm_uc_crypto_hmac_mbedtls.c arm_uc_metadata_header_v2.c
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-metadata-header-update-client-metadata-header
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/metadata-header/update-client-metadata-header/: arm_uc_buffer_utilities.h arm_uc_metadata_header_v2.h
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-monitor
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/monitor/: LICENSE
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-monitor-update-client-monitor
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/monitor/update-client-monitor/: arm_uc_monitor.h
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-paal
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/paal/: LICENSE
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-paal-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/paal/source/: arm_uc_paal_update.c
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-paal-update-client-paal
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/paal/update-client-paal/: arm_uc_paal_update.h arm_uc_paal_update_api.h
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-pal-blockdevice-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/pal-blockdevice/source/: arm_uc_pal_blockdevice.c arm_uc_pal_blockdevice_implementation.c arm_uc_pal_blockdevice_mbed.cpp
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-pal-blockdevice-update-client-pal-blockdevice
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/pal-blockdevice/update-client-pal-blockdevice/: arm_uc_pal_blockdevice.h arm_uc_pal_blockdevice_implementation.h arm_uc_pal_blockdevice_platform.h
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-pal-flashiap-mcuboot
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/pal-flashiap-mcuboot/: LICENSE
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-pal-flashiap-mcuboot-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/pal-flashiap-mcuboot/source/: arm_uc_pal_flashiap_flash.cpp arm_uc_pal_flashiap_mcuboot.c arm_uc_pal_flashiap_mcuboot_implementation.c
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-pal-flashiap
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/pal-flashiap/: LICENSE
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-pal-flashiap-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/pal-flashiap/source/: arm_uc_pal_flashiap.c arm_uc_pal_flashiap_implementation.c arm_uc_pal_flashiap_mbed.cpp
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-pal-flashiap-update-client-pal-flashiap
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/pal-flashiap/update-client-pal-flashiap/: arm_uc_pal_flashiap.h arm_uc_pal_flashiap_implementation.h arm_uc_pal_flashiap_platform.h
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-source-http
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/source-http/: LICENSE
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-source-http-update-client-source-http
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/source-http/update-client-source-http/: arm_uc_source_http.h arm_uc_source_http_extra.h
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-source-manager
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/source-manager/: LICENSE
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-source-manager-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/source-manager/source/: arm_uc_source_manager.c
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-source-manager-update-client-source-manager
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/source-manager/update-client-source-manager/: arm_uc_source_manager.h
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/source/: LICENSE
  group arm-pelion-mbed-cloud-client-update-client-hub-modules-source-update-client-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/modules/source/update-client-source/: arm_uc_source.h
  group arm-pelion-mbed-cloud-client-update-client-hub-source
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/source/: update_client_hub.c update_client_hub_error_handler.c update_client_hub_error_handler.h update_client_hub_event_handlers.c update_client_hub_event_handlers.h update_client_hub_state_machine.c update_client_hub_state_machine.h
  group arm-pelion-mbed-cloud-client-update-client-hub-update-client-hub
    ../../../../../middleware/arm-pelion/mbed-cloud-client/update-client-hub/update-client-hub/: update_client_certificate.h update_client_hub.h update_client_public.h
  group device
    ../../../../../devices/MIMXRT1062/: MIMXRT1062.h MIMXRT1062_features.h fsl_device_registers.h system_MIMXRT1062.c system_MIMXRT1062.h
  group component-uart
    ../../../../../components/uart/: lpuart_adapter.c uart.h
  group component-serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MIMXRT1062/arm/: startup_MIMXRT1062.S
  group xip
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
    ../../../xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h mpu_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h arm_common_tables.h arm_const_structs.h arm_math.h
  group freertos-freertos_kernel
    ../../../../../rtos/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos-freertos_kernel-include
    ../../../../../rtos/freertos/freertos_kernel/include/: FreeRTOS.h StackMacros.h atomic.h croutine.h deprecated_definitions.h event_groups.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos-freertos_kernel-portable-GCC-ARM_CM4F
    ../../../../../rtos/freertos/freertos_kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group freertos-freertos_kernel-portable
    ../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
target arm_pelion_enet flexspi_nor_release (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.2.3.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: arm_pelion_enet.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, NDEBUG, CPU_MIMXRT1062DVL6A, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, SKIP_SYSCLK_INIT, FLASHIAP_APP_ROM_END_ADDR=1614807040, MBED_CONF_STORAGE_STORAGE_TYPE=TDB_INTERNAL, MBED_CONF_STORAGE_TDB_INTERNAL_INTERNAL_BASE_ADDRESS=1618935808, MBED_CONF_STORAGE_TDB_INTERNAL_INTERNAL_SIZE=65536, MBED_CLOUD_CLIENT_UPDATE_STORAGE=ARM_UCP_FLASHIAP, MBED_CONF_UPDATE_CLIENT_STORAGE_ADDRESS=1614807040, MBED_CONF_UPDATE_CLIENT_STORAGE_LOCATIONS=1, MBED_CONF_UPDATE_CLIENT_STORAGE_PAGE=256, MBED_CONF_UPDATE_CLIENT_STORAGE_SIZE=4128768, MBED_CONF_UPDATE_CLIENT_APPLICATION_DETAILS=1610678272, UPDATE_CLIENT_STORAGE_FLASHIAP, PRINTF_ADVANCED_ENABLE=0, PRINTF_FLOAT_ENABLE=0, USE_RTOS=1, __NXP_FREERTOS__, MBED_CLIENT_USER_CONFIG_FILE='\"mbed_cloud_client_user_config.h\"', MBED_CLOUD_CLIENT_USER_CONFIG_FILE='\"mbed_cloud_client_user_config.h\"', PAL_USER_DEFINED_CONFIGURATION='\"pal_config_NXP.h\"', MBEDTLS_CONFIG_FILE='\"mbedTLSConfig_NXP.h\"', MBED_CONF_NS_HAL_PAL_EVENT_LOOP_THREAD_STACK_SIZE=8000, PAL_DTLS_PEER_MIN_TIMEOUT=5000, MBED_CONF_MBED_CLOUD_CLIENT_UPDATE_DOWNLOAD_PROTOCOL=MBED_CLOUD_CLIENT_UPDATE_DOWNLOAD_PROTOCOL_COAP, COMPONENT_FLASHIAP, ARM_UC_PROFILE_MBED_CLOUD_CLIENT=1, ARM_UC_FEATURE_DELTA_PAAL=0, ATOMIC_QUEUE_USE_PAL=1, ARM_UC_FEATURE_PAL_FLASHIAP=1, MBED_CONF_MBED_CLOUD_CLIENT_EXTERNAL_SST_SUPPORT=1, PAL_USE_FILESYSTEM=0, MBED_CONF_MBED_TRACE_ENABLE=0, MBED_TRACE_MAX_LEVEL=TRACE_LEVEL_ERROR, MBED_CONF_APP_DEVELOPER_MODE=1, PLATFORM_ENABLE_BUTTON=1, PLATFORM_ENABLE_LED=1, MBED_CLOUD_APPLICATION_NONSTANDARD_ENTRYPOINT, LWIP_DHCP=1, LWIP_DNS=1, LWIP_IPV6=1, LWIP_NETIF_LINK_CALLBACK=1, LWIP_NETIF_STATUS_CALLBACK=1, LWIP_SO_SNDTIMEO=1, MBED_CLOUD_CLIENT_SUPPORT_UPDATE, PAL_SEMAPHORE_MAX_COUNT=4096, PAL_SKIP_TEST_MODULE_CRYPTO=1, PAL_SKIP_TEST_MODULE_DRBG=1, PAL_SKIP_TEST_MODULE_FILESYSTEM=1, PAL_SKIP_TEST_MODULE_INTERNALFLASH=1, PAL_SKIP_TEST_MODULE_ROT=1, PAL_SKIP_TEST_MODULE_SOTP=1, PAL_SKIP_TEST_MODULE_SST=1, PAL_SKIP_TEST_MODULE_TIME=1, PAL_SKIP_TEST_MODULE_TLS=1, PAL_SKIP_TEST_MODULE_UPDATE=1, __USE_CMSIS, RBP_TESTING, DEVICE_FLASH, SDK_DEBUGCONSOLE_UART, MBED_CONF_NANOSTACK_EVENTLOOP_EXCLUDE_HIGHRES_TIMER, MBED_CONF_NANOSTACK_EVENTLOOP_USE_PLATFORM_TICK_TIMER, MBED_CONF_MBED_CLIENT_SN_COAP_DUPLICATION_MAX_MSGS_COUNT=4, SN_COAP_REDUCE_BLOCKWISE_HEAP_FOOTPRINT=1, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..;../../..
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: as above
