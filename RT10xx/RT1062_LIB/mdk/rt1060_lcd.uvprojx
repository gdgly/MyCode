# Keil uVision project rt1060_lcd.uvprojx, settings and files
target Target 1 (6130001::V6.13.1::.\ARMCLANG)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.12.2.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x00200000,0x020000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt1060_lcd +hex (library)
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\AwtkSrc\awtk\3rd;.\AwtkSrc\awtk\3rd\agge;.\AwtkSrc\awtk\3rd\stb;.\AwtkSrc\awtk\3rd\nanovg;.\AwtkSrc\awtk\3rd\nanovg\base;.\AwtkSrc\awtk\3rd\libunibreak;.\AwtkSrc\awtk\3rd\gpinyin\include;.\AwtkSrc\awtk\src;.\AwtkSrc\awtk\src\ext_widgets;.\AwtkSrc\awtk-port
  memory RVCT4: ROM 0x200000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  group AwtkSrc
    ./AwtkSrc/awtk/3rd/libunibreak/: emojidef.c graphemebreak.c linebreak.c linebreakdata.c linebreakdef.c unibreakbase.c unibreakdef.c wordbreak.c
    ./AwtkSrc/awtk/3rd/nanovg/base/: nanovg.c
    ./AwtkSrc/awtk/3rd/agge/agge/: math.cpp stroke.cpp stroke_features.cpp vector_rasterizer.cpp
    ./AwtkSrc/awtk/3rd/gpinyin/src/: dictlist.cpp dicttrie.cpp lpicache.cpp matrixsearch.cpp mystdlib.cpp ngram.cpp pinyinime.cpp searchutility.cpp spellingtrie.cpp splparser.cpp utf16char.cpp
    ./AwtkSrc/awtk/3rd/nanovg/agge/: nanovg_agge.cpp nanovg_vertex.cpp
    ./AwtkSrc/awtk/src/base/: asset_loader.c asset_loader_default.c asset_loader_zip.c assets_manager.c bidi.c bitmap.c canvas.c children_layouter.c children_layouter_factory.c clip_board.c data_reader_asset.c date_time_format.c dialog.c dialog_highlighter.c dialog_highlighter_factory.c enums.c event_queue.c event_recorder_player.c events.c font.c font_loader.c font_manager.c glyph_cache.c graphic_buffer.c hscrollable.c idle.c image_base.c image_loader.c image_manager.c input_device_status.c input_engine.c input_method.c layout.c lcd.c lcd_profile.c line_break.c locale_info.c main_loop.c native_window.c self_layouter.c self_layouter_factory.c shortcut.c style.c style_const.c style_factory.c style_mutable.c suggest_words.c system_info.c text_edit.c theme.c timer.c ui_builder.c ui_feedback.c ui_loader.c velocity.c vgcanvas.c widget.c widget_animator.c widget_animator_factory_null.c widget_animator_manager.c widget_factory.c widget_vtable.c window.c window_animator.c window_animator_factory.c window_base.c window_manager.c
    ./AwtkSrc/awtk/src/blend/: blend_image_bgr565_bgr565.c blend_image_bgr565_bgra8888.c blend_image_bgr565_rgb565.c blend_image_bgr565_rgba8888.c blend_image_bgr888_bgr565.c blend_image_bgr888_bgr888.c blend_image_bgr888_bgra8888.c blend_image_bgr888_rgb565.c blend_image_bgr888_rgba8888.c blend_image_bgra8888_bgr565.c blend_image_bgra8888_bgra8888.c blend_image_bgra8888_rgb565.c blend_image_bgra8888_rgba8888.c blend_image_rgb565_bgr565.c blend_image_rgb565_bgra8888.c blend_image_rgb565_rgb565.c blend_image_rgb565_rgba8888.c blend_image_rgb888_bgr565.c blend_image_rgb888_bgra8888.c blend_image_rgb888_rgb565.c blend_image_rgb888_rgb888.c blend_image_rgb888_rgba8888.c blend_image_rgba8888_bgr565.c blend_image_rgba8888_bgra8888.c blend_image_rgba8888_rgb565.c blend_image_rgba8888_rgba8888.c fill_image_abgr8888.c fill_image_argb8888.c fill_image_bgr565.c fill_image_bgr888.c fill_image_bgra8888.c fill_image_rgb565.c fill_image_rgb888.c fill_image_rgba8888.c image_g2d.c rotate_image_bgr565.c rotate_image_bgr888.c rotate_image_bgra8888.c rotate_image_rgb565.c rotate_image_rgb888.c rotate_image_rgba8888.c soft_g2d.c stm32_g2d.c
    ./AwtkSrc/awtk/src/clip_board/: clip_board_default.c clip_board_sdl.c
    ./AwtkSrc/awtk/src/dialog_highlighters/: dialog_highlighter_builtins.c dialog_highlighter_default.c
    ./AwtkSrc/awtk/src/ext_widgets/canvas_widget/: canvas_widget.c
    ./AwtkSrc/awtk/src/ext_widgets/color_picker/: color_component.c color_picker.c rgb_and_hsv.c
    ./AwtkSrc/awtk/src/ext_widgets/combo_box_ex/: combo_box_ex.c
    ./AwtkSrc/awtk/src/ext_widgets/features/: draggable.c
    ./AwtkSrc/awtk/src/ext_widgets/file_browser/: file_browser.c file_browser_view.c file_chooser.c
    ./AwtkSrc/awtk/src/ext_widgets/gif_image/: gif_image.c
    ./AwtkSrc/awtk/src/ext_widgets/guage/: guage.c guage_pointer.c
    ./AwtkSrc/awtk/src/ext_widgets/image_animation/: image_animation.c
    ./AwtkSrc/awtk/src/ext_widgets/image_value/: image_value.c
    ./AwtkSrc/awtk/src/ext_widgets/keyboard/: candidates.c keyboard.c lang_indicator.c
    ./AwtkSrc/awtk/src/ext_widgets/mledit/: line_number.c mledit.c
    ./AwtkSrc/awtk/src/ext_widgets/mutable_image/: mutable_image.c
    ./AwtkSrc/awtk/src/ext_widgets/progress_circle/: progress_circle.c
    ./AwtkSrc/awtk/src/ext_widgets/rich_text/: rich_text.c rich_text_node.c rich_text_parser.c rich_text_render_node.c rich_text_view.c
    ./AwtkSrc/awtk/src/ext_widgets/scroll_label/: hscroll_label.c
    ./AwtkSrc/awtk/src/ext_widgets/scroll_view/: children_layouter_list_view.c list_item.c list_view.c list_view_h.c scroll_bar.c scroll_view.c
    ./AwtkSrc/awtk/src/ext_widgets/slide_menu/: slide_menu.c
    ./AwtkSrc/awtk/src/ext_widgets/slide_view/: slide_indicator.c slide_view.c
    ./AwtkSrc/awtk/src/ext_widgets/svg_image/: svg_image.c
    ./AwtkSrc/awtk/src/ext_widgets/switch/: switch.c
    ./AwtkSrc/awtk/src/ext_widgets/text_selector/: text_selector.c
    ./AwtkSrc/awtk/src/ext_widgets/time_clock/: time_clock.c
    ./AwtkSrc/awtk/src/ext_widgets/: ext_widgets.c
    ./AwtkSrc/awtk/src/font_loader/: font_loader_bitmap.c font_loader_ft.c font_loader_stb.c
    ./AwtkSrc/awtk/src/graphic_buffer/: graphic_buffer_default.c
    ./AwtkSrc/awtk/src/image_loader/: image_loader_stb.c
    ./AwtkSrc/awtk/src/input_engines/: input_engine_pinyin.cpp
    ./AwtkSrc/awtk/src/input_methods/: input_method_creator.c
    ./AwtkSrc/awtk/src/layouters/: children_layouter_builtins.c children_layouter_default.c children_layouter_parser.c self_layouter_builtins.c self_layouter_default.c self_layouter_menu.c self_layouter_parser.c
    ./AwtkSrc/awtk/src/lcd/: lcd_mem_bgr565.c lcd_mem_bgra8888.c lcd_mem_rgb565.c lcd_mem_rgba8888.c
    ./AwtkSrc/awtk/src/main_loop/: main_loop_simple.c
    ./AwtkSrc/awtk/src/misc/: new.cpp test_cpp.cpp
    ./AwtkSrc/awtk/src/native_window/: native_window_raw.c
    ./AwtkSrc/awtk/src/svg/: bsvg.c bsvg_builder.c bsvg_draw.c bsvg_to_svg.c svg_path.c svg_path_parser.c svg_shape.c svg_to_bsvg.c
    ./AwtkSrc/awtk/src/tkc/: action_queue.c action_thread.c action_thread_pool.c asset_info.c async.c buffer.c color.c color_parser.c compressor.c cond_var.c crc.c darray.c data_reader.c data_reader_factory.c data_reader_file.c data_writer.c data_writer_factory.c data_writer_file.c date_time.c easing.c emitter.c event.c event_source.c event_source_fd.c event_source_idle.c event_source_manager.c event_source_manager_default.c event_source_timer.c expr_eval.c fs.c func_call_parser.c idle_info.c idle_manager.c int_str.c iostream.c istream.c log.c matrix.c mem.c mutex_nest.c named_value.c object.c object_array.c object_compositor.c object_default.c object_locker.c ostream.c path.c plugin_manager.c qaction.c rect.c ring_buffer.c rom_fs.c slist.c socket_helper.c socket_pair.c str.c str_str.c time_now.c timer_info.c timer_manager.c tokenizer.c utf8.c utils.c value.c value_desc.c waitable_action_queue.c waitable_ring_buffer.c wstr.c
    ./AwtkSrc/awtk/src/ui_loader/: ui_binary_writer.c ui_builder_default.c ui_loader_default.c ui_loader_xml.c ui_serializer.c ui_xml_writer.c window_open.c
    ./AwtkSrc/awtk/src/vgcanvas/: vgcanvas_nanovg_soft.c
    ./AwtkSrc/awtk/src/widget_animators/: widget_animator_factory.c widget_animator_prop.c widget_animator_prop2.c widget_animator_scroll.c
    ./AwtkSrc/awtk/src/widgets/: app_bar.c button.c button_group.c calibration_win.c check_button.c clip_view.c color_tile.c column.c combo_box.c combo_box_item.c dialog_client.c dialog_helper.c dialog_title.c digit_clock.c dragger.c edit.c grid.c grid_item.c group_box.c image.c label.c overlay.c pages.c popup.c progress_bar.c row.c slider.c spin_box.c system_bar.c tab_button.c tab_button_group.c tab_control.c view.c widgets.c
    ./AwtkSrc/awtk/src/window_animators/: window_animator_builtins.c window_animator_center_scale.c window_animator_common.c window_animator_fade.c window_animator_htranslate.c window_animator_popdown.c window_animator_popup.c window_animator_slide.c window_animator_slide_down.c window_animator_slide_left.c window_animator_slide_right.c window_animator_slide_up.c window_animator_vtranslate.c
    ./AwtkSrc/awtk/src/window_manager/: window_manager_default.c
    ./AwtkSrc/awtk/src/xml/: xml_builder.c xml_parser.c
    ./AwtkSrc/awtk/src/: awtk_global.c
software components: CMSIS:CORE 5.4.0
