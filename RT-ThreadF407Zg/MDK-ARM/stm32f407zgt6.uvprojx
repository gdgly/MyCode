# Keil uVision project stm32f407zgt6.uvprojx, settings and files
target stm32f407zgt6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: stm32f407zgt6
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Middlewares\RTT;..\Middlewares\rt-thread\src;..\Middlewares\rt-thread\include\libc;..\Middlewares\rt-thread\include;..\Middlewares\rt-thread\components\drivers\can;..\Middlewares\rt-thread\components\drivers\rtc;..\Middlewares\rt-thread\components\drivers\serial;..\Middlewares\rt-thread\components\drivers\spi;..\Middlewares\rt-thread\components\drivers\watchdog;..\Middlewares\rt-thread\components\drivers\misc;..\Middlewares\rt-thread\bsp\stm32\libraries\HAL_Drivers;..\Middlewares\rt-thread\bsp\stm32\libraries\HAL_Drivers\drv_flash;..\Middlewares\rt-thread\libcpu\arm\cortex-m4;..\Middlewares\rt-thread\components\utilities\ulog;..\Middlewares\rt-thread\components\utilities\ulog\backend;..\Middlewares\rt-thread\components\drivers\include\drivers;..\App;..\Middlewares\rt-thread\components\drivers\include;..\Middlewares\rt-thread\components\net\at\include;..\Middlewares\rt-thread\components\libc\compilers\armlibc\sys;..\Middlewares\rt-thread\bsp\stm32\libraries\HAL_Drivers\config\f4;..\Middlewares\rt-thread\bsp\stm32\libraries\HAL_Drivers\config;..\Middlewares\rt-thread\components\libc\compilers\armlibc;..\Middlewares\rt-thread\libcpu\arm\common;..\Middlewares\rt-thread\components\drivers\sdio;..\Middlewares\rt-thread\components\dfs\include;..\Middlewares\rt-thread\components\dfs\filesystems\elmfat;..\Middlewares\rt-thread\components\dfs\filesystems\elmfat\option;..\Middlewares\rt-thread\components\drivers\can;..\Middlewares\rt-thread\components\drivers\spi\sfud\inc;..\Middlewares\rt-thread\components\drivers\include;..\Middlewares\rt-thread\components\drivers\include\ipc;..\Middlewares\rt-thread\bsp\stm32\libraries\Sensor\inc;..\Middlewares\rt-thread\components\drivers\sensors
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../App/: app_console.c app_test.c app_main.c board.c rtconfig.h
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c adc.c can.c dac.c i2c.c iwdg.c rtc.c sdio.c spi.c sys.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/RTT
    ../Middlewares/RTT/: SEGGER_RTT.c
  group Middlewares/RT_Thread/Kernel
    ../Middlewares/rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c
  group Middlewares/RT_Thread/Port
    ../Middlewares/rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../Middlewares/rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Middlewares/RT_Thread/libc
    ../Middlewares/rt-thread/components/libc/compilers/armlibc/: libc.c libc_syms.c mem_std.c stdio.c stubs.c time.c
  group Middlewares/RT_Thread/device_drivers
    ../Middlewares/rt-thread/components/drivers/rtc/: rtc.c
    ../Middlewares/rt-thread/components/drivers/misc/: pin.c adc.c
    ../Middlewares/rt-thread/components/drivers/serial/: serial.c
    ../Middlewares/rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../Middlewares/rt-thread/components/drivers/spi/: spi_dev.c spi_core.c spi_flash_sfud.c
    ../Middlewares/rt-thread/components/drivers/watchdog/: watchdog.c
    ../Middlewares/rt-thread/components/net/at/src/: at_client.c at_utils.c
    ../Middlewares/rt-thread/components/drivers/src/: completion.c
    ../Middlewares/rt-thread/components/drivers/can/: can.c
    ../Middlewares/rt-thread/components/drivers/sdio/: block_dev.c sd.c sdio.c mmc.c mmcsd_core.c
    ../Middlewares/rt-thread/components/drivers/sensors/: sensor.c sensor_cmd.c
  group Middlewares/RT_Thread/bsp
    ../Middlewares/rt-thread/bsp/stm32/libraries/HAL_Drivers/: drv_adc.c drv_rtc.c drv_spi.c drv_spi_flash.c drv_usart.c drv_wdt.c drv_common.c drv_gpio.c drv_sdio_sd.c drv_can.c
    ../Middlewares/rt-thread/bsp/stm32/libraries/HAL_Drivers/drv_flash/: drv_flash_f4.c
  group Middlewares/RT_Thread/utilities
    ../Middlewares/rt-thread/components/utilities/ulog/: ulog.c
    ../Middlewares/rt-thread/components/utilities/ulog/backend/: console_be.c
  group Middlewares/RT_Thread/dfs
    ../Middlewares/rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Middlewares/RT_Thread/filesystem
    ../Middlewares/rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group Middlewares/RT_Thread/ring_buffer
    ../Middlewares/rt-thread/components/drivers/src/: ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c dataqueue.c
  group Middlewares/RT_Thread/sensor
    ../Middlewares/rt-thread/bsp/stm32/libraries/Sensor/src/: lsm6ds0.c sensor_inven_lsm6ds0.c
software components: CMSIS:CORE 4.3.0
